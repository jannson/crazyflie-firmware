# Keil uVision project crazyflie.uvproj, settings and files
target cflie (ARM-GNU)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cflie +hex
  AfterMake: E:\project\crazy\crazyflie-firmware\end_build.bat
  group drivers
    ./drivers/src/: adc.c exti.c hmc5883l.c i2cdev.c i2croutines.c led.c motors.c mpu6050.c ms5611.c nrf24l01.c nvic.c
    ./: version.c
  group hal
    ./hal/src/: eskylink.c freeRTOSdebug.c imu.c ledseq.c pm.c radiolink.c uart.c usec_time.c
  group init
    ./init/: main.c
  group lib
    ./lib/CMSIS/Core/CM3/startup/gcc/: startup_stm32f10x_md.s
    ./lib/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./lib/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ./lib/FreeRTOS/portable/MemMang/: heap_4.c
    ./lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dma.c misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group modules
    ./modules/src/: comm.c commander.c console.c controller.c crtp.c crtpservice.c log.c param.c pid.c pidctrl.c sensfusion6.c stabilizer.c system.c worker.c
  group utils
    ./utils/src/: abort.c cfassert.c configblock.c cpuid.c crc.c debug.c eprintf.c filter.c fp16.c
